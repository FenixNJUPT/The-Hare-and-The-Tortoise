# Keil uVision project 贪吃蛇源代码.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 贪吃蛇源代码 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Drivers;.\USER
  group startup
    ./: STARTUP.A51
  group USER
    ./: main.c
    ./USER/: snake.c delay.c key.c interrupt.c
  group Drivers
    ./Drivers/: 8x8lattice.c
